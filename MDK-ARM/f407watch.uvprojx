# Keil uVision project f407watch.uvprojx, settings and files
target f407watch (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f407watch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/CST816;../BSP/IIC;../SYSTEM;../Middlewares/LVGL/lvgl;../Middlewares/LVGL;../Middlewares/LVGL/lvgl/examples/porting;../BSP/LCD;../UI/generated;../UI/custom;../BSP/rtc_port
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c rtc.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/CST816/: CST816.c
    ../BSP/IIC/: iic_hal.c
    ../BSP/LCD/: lcd.c lcd_init.c
    ../BSP/rtc_port/: rtc_port.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group Middlewares/LVGL/src
    ../Middlewares/LVGL/lvgl/src/: lv_init.c
  group Middlewares/LVGL/src/core
    ../Middlewares/LVGL/lvgl/src/core/: lv_group.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c
  group Middlewares/LVGL/src/display
    ../Middlewares/LVGL/lvgl/src/display/: lv_display.c
  group Middlewares/LVGL/src/draw
    ../Middlewares/LVGL/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middlewares/LVGL/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/LVGL/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middlewares/LVGL/lvgl/src/draw/dma2d/: lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d.c
    ../Middlewares/LVGL/lvgl/src/draw/espressif/ppa/: lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c lv_draw_ppa.c
    ../Middlewares/LVGL/lvgl/src/draw/eve/: lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_draw_eve.c lv_eve.c
    ../Middlewares/LVGL/lvgl/src/draw/: lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_draw.c lv_image_decoder.c
    ../Middlewares/LVGL/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_draw_nema_gfx.c lv_nema_gfx_path.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_draw_g2d.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_draw_pxp.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Middlewares/LVGL/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d.c
    ../Middlewares/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask_rect.c lv_draw_sw_mask.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c lv_draw_sw.c
    ../Middlewares/LVGL/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_draw_vg_lite.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group Middlewares/LVGL/src/font
    ../Middlewares/LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14_aligned.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
  group Middlewares/LVGL/src/indev
    ../Middlewares/LVGL/lvgl/src/indev/: lv_indev_gesture.c lv_indev_scroll.c lv_indev.c
  group Middlewares/LVGL/src/layouts
    ../Middlewares/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/lvgl/src/layouts/: lv_layout.c
  group Middlewares/LVGL/src/libs
    ../Middlewares/LVGL/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/LVGL/lvgl/src/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok_impl.c xmltok_ns.c xmltok.c
    ../Middlewares/LVGL/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/lvgl/src/libs/freetype/: lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype.c lv_ftsystem.c
    ../Middlewares/LVGL/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../Middlewares/LVGL/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Middlewares/LVGL/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../Middlewares/LVGL/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../Middlewares/LVGL/lvgl/src/libs/gif/: lv_gif.c
    ../Middlewares/LVGL/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../Middlewares/LVGL/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../Middlewares/LVGL/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../Middlewares/LVGL/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Middlewares/LVGL/lvgl/src/libs/libpng/: lv_libpng.c
    ../Middlewares/LVGL/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Middlewares/LVGL/lvgl/src/libs/lz4/: lz4.c
    ../Middlewares/LVGL/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/lvgl/src/libs/rle/: lv_rle.c
    ../Middlewares/LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/lvgl/src/libs/svg/: lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c lv_svg.c
    ../Middlewares/LVGL/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/LVGL/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Middlewares/LVGL/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../Middlewares/LVGL/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c vg_lite.c
    ../Middlewares/LVGL/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
  group Middlewares/LVGL/src/misc
    ../Middlewares/LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/LVGL/lvgl/src/misc/cache/: lv_cache_entry.c lv_cache.c
    ../Middlewares/LVGL/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color_op.c lv_color.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin_posix.c lv_profiler_builtin.c lv_rb.c lv_style_gen.c lv_style.c lv_templ.c lv_text_ap.c lv_text.c lv_timer.c lv_tree.c lv_utils.c
  group Middlewares/LVGL/src/osal
    ../Middlewares/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os_none.c lv_os.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group Middlewares/LVGL/src/others
    ../Middlewares/LVGL/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/LVGL/lvgl/src/others/font_manager/: lv_font_manager_recycle.c lv_font_manager.c
    ../Middlewares/LVGL/lvgl/src/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ../Middlewares/LVGL/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/lvgl/src/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/lvgl/src/others/observer/: lv_observer.c
    ../Middlewares/LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
    ../Middlewares/LVGL/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev_gesture.c lv_test_indev.c lv_test_screenshot_compare.c
    ../Middlewares/LVGL/lvgl/src/others/translation/: lv_translation.c
    ../Middlewares/LVGL/lvgl/src/others/xml/: lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c lv_xml.c
    ../Middlewares/LVGL/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group Middlewares/LVGL/src/stdlib
    ../Middlewares/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/LVGL/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group Middlewares/LVGL/src/themes
    ../Middlewares/LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/lvgl/src/themes/: lv_theme.c
    ../Middlewares/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
  group Middlewares/LVGL/src/tick
    ../Middlewares/LVGL/lvgl/src/tick/: lv_tick.c
  group Middlewares/LVGL/src/widgets
    ../Middlewares/LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/LVGL/lvgl/src/widgets/calendar/: lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../Middlewares/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/lvgl/src/widgets/win/: lv_win.c
  group Middlewares/LVGL/example/porting
    ../Middlewares/LVGL/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group UI
    ../UI/custom/: custom.c
    ../UI/generated/: gg_utils.c
    ../UI/generated/assets/fonts/: lv_font_montserratMedium_30.c
    ../UI/generated/events/: gg_event_layer_bottom.c gg_event_layer_sys.c gg_event_layer_top.c gg_event_screen.c gg_event_screen_1.c gg_event_SetTimeScreen.c
    ../UI/generated/screens/: gg_layer_bottom.c gg_layer_sys.c gg_layer_top.c gg_screen.c gg_screen_1.c gg_SetTimeScreen.c
software components: CMSIS:CORE 4.3.0
